# Keil uVision project STM32_USB_CDC_HS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32_USB_CDC_HS +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_HAL_DRIVER,STM32F407xx,USE_STM32F4_DISCO,USE_USB_FS,USE_ULPI_PHY
  c include: .\cmsisboot;.\cmsiscore;.\Hardware\Common;.\Hardware\lis302dl;.\Hardware\lis3dsh;.\STM32F4xx_HAL_Driver\Inc;.\STM32_USB_Device_Library\Core\Inc;.\User;.\STM32_USB_Device_Library\Class\CDC\Inc;.\Hardware;.\Hardware\cs43l22;.\Middlewares
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares
    ./Middlewares/: libPDMFilter_CM4F_Keil.lib
  group cmsiscore
    ./cmsiscore/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group cmsisboot
    ./cmsisboot/: startup_stm32f407xx.s system_stm32f4xx.c
  group usb_class
    ./STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group HardWare
    ./Hardware/cs43l22/: cs43l22.c
    ./Hardware/lis3dsh/: lis3dsh.c
    ./Hardware/lis302dl/: lis302dl.c
  group board
    ./Hardware/: stm32f4_discovery.c stm32f4_discovery_accelerometer.c stm32f4_discovery_audio.c
  group usb_lib
    ./STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group std_lib
    ./STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group user
    ./User/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usbd_cdc_interface.c usbd_desc.c usbd_conf.c
