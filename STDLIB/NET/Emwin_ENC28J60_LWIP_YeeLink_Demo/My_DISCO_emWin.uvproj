# Keil uVision project My_DISCO_emWin.uvproj, settings and files
target Emwin_LWIP_YeeLink_Demo (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: My_DISCO_emWin +hex
  c flags: Optim=1
  c include: .\BSP;.\Cmsis_Boot;.\Cmsis_Core;.\emWin522\Config;.\emWin522\inc;.\StdPeriph_Driver\inc;.\USER;.\My_Driver_Config;.\My_BSP_Driver\SSD1963;.\My_BSP_Driver\ENC28J60;.\LwIP\include;.\LwIP\app;.\LwIP\arch;.\LwIP\include\ipv4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Cmsis_Core
    ./Cmsis_Core/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group Cmsis_Boot
    ./Cmsis_Boot/: startup_stm32f40xx.s stm32f4xx.h system_stm32f4xx.h system_stm32f4xx.c
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Emwin522-Lib
    ./emWin522/Lib/: STemWin522_CM4_Keil.lib
  group Emwin522-Config
    ./emWin522/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
  group Emwin522-OS
    ./emWin522/OS/: GUI_X.c
  group BSP
    ./BSP/: My_DISCO_BSP.c My_DISCO_BSP.h My_DISCO_BSP_Config.h My_DISCO_BSP_DeBug.c My_DISCO_BSP_Debug.h
  group My_BSP_Driver
    ./My_BSP_Driver/SSD1963/: SSD1963.c SSD1963.h
    ./My_BSP_Driver/ENC28J60/: ENC28J60.c ENC28J60.h
  group My_BSP_Driver_Config
    ./My_Driver_Config/: SSD1963_config.h ENC28J60_Config.h
  group lwip-api
    ./LwIP/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip-core
    ./LwIP/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys_lwip.c tcp.c tcp_in.c tcp_out.c timers_lwip.c udp.c
  group lwip-core-ipv4
    ./LwIP/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwip-snmp
    ./LwIP/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group lwip-neiif
    ./LwIP/netif/: etharp.c ethernetif.c
  group lwip-arch
    ./LwIP/arch/: sys_arch.c cc.h cpu.h perf.h sys_arch.h
  group lwip-app
    ./LwIP/app/: cmd.c httpd.c netconfig.c cmd.h httpd.h lwipopts.h netconfig.h web_html.h http_YeeLink.c http_YeeLink.h
  group USER
    ./USER/: main.c main.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
