# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\inc;..\board\inc;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Third_Party\uCOS-II\Ports;..\Third_Party\uCOS-II\Source;..\Third_Party\uCOS-II\uC-CPU;..\Third_Party\uCGUI\Config;..\Third_Party\uCGUI\includes;..\Third_Party\uCOS-II\uC-LIB;..\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./: startup_stm32f4xx.s
  group user
    ../src/: main.c bsp.c stm32f4xx_it.c system_stm32f4xx.c
    ../inc/: os_cfg.h app_cfg.h
  group board
    ../board/src/: led.c key.c usart.c TFT.c touch.c spi.c delay.c
  group ucosII
    ../Third_Party/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu.h os_cpu_a.asm
    ../Third_Party/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../Third_Party/uCOS-II/uC-CPU/: cpu_def.h cpu.h cpu_a.asm
  group lib
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
